# IAR project BLE_MS_Formula.ewp, settings and files
configuration Master_Slave (ARM, debug)
  General.OGChipSelectEditMenu: BlueNRG-1 ST BlueNRG-1
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: USER_BUTTON=BUTTON_1; HS_SPEED_XTAL=HS_SPEED_XTAL_16MHZ; LS_SOURCE=LS_SOURCE_EXTERNAL_32KHZ; SMPS_INDUCTOR=SMPS_INDUCTOR_10uH; BLE_STACK_CONFIGURATION=BLE_STACK_FULL_CONFIGURATION; MASTER_SLAVE=1; MASTER_SLAVE_NUM_MASTERS=1; MASTER_SLAVE_NUM_SLAVES=6; MASTER_SLAVE_SCAN_WINDOW=20.00; MASTER_SLAVE_SLEEP_TIME=0.00
  ICCARM.CCIncludePath2: ..\..\inc; ..\..\..\..\..\Library\hal\inc; ..\..\..\..\..\Library\BlueNRG1_Periph_Driver\inc; ..\..\..\..\..\Library\CMSIS\Device\ST\BlueNRG1\Include; ..\..\..\..\..\Library\CMSIS\Include; ..\..\..\..\..\Library\Bluetooth_LE\inc; ..\..\..\..\..\Library\BLE_Application\layers_inc; ..\..\..\..\..\Library\BLE_Application\Utils\inc; ..\..\..\..\..\Library\BLE_Application\OTA\inc; ..\..\..\..\..\Library\SDK_Eval_BlueNRG1\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: BLE_MS_Formula_Master_Slave.hex
  postbuild: ielftool.exe --bin --verbose "$TARGET_PATH$" "$TARGET_DIR$\BLE_MS_Formula_Master_Slave.bin"
  ILINK.IlinkOutputFile: BLE_MS_Formula_Master_Slave.out
  ILINK.IlinkIcfFile: BlueNRG1.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Master (ARM, debug)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USER_BUTTON=BUTTON_1; HS_SPEED_XTAL=HS_SPEED_XTAL_16MHZ; LS_SOURCE=LS_SOURCE_EXTERNAL_32KHZ; SMPS_INDUCTOR=SMPS_INDUCTOR_10uH; BLE_STACK_CONFIGURATION=BLE_STACK_FULL_CONFIGURATION; MASTER=1
  OBJCOPY.OOCOutputFile: BLE_MS_Formula_Master.hex
  postbuild: ielftool.exe --bin --verbose "$TARGET_PATH$" "$TARGET_DIR$\BLE_MS_Formula_Master.bin"
  ILINK.IlinkOutputFile: BLE_MS_Formula_Master.out
configuration Slave (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USER_BUTTON=BUTTON_1; HS_SPEED_XTAL=HS_SPEED_XTAL_16MHZ; LS_SOURCE=LS_SOURCE_EXTERNAL_32KHZ; SMPS_INDUCTOR=SMPS_INDUCTOR_10uH; BLE_STACK_CONFIGURATION=BLE_STACK_FULL_CONFIGURATION; SLAVE=1
  group HAL
    ../../../../../Library/hal/src/: clock.c context_switch.s gp_timer.c miscutil.c osal.c sleep.c
  group Library
    ../../../../../Library/BlueNRG1_Periph_Driver/src/: BlueNRG1_adc.c BlueNRG1_dma.c BlueNRG1_flash.c BlueNRG1_gpio.c BlueNRG1_i2c.c BlueNRG1_mft.c BlueNRG1_pka.c BlueNRG1_rng.c BlueNRG1_rtc.c BlueNRG1_spi.c BlueNRG1_sysCtrl.c BlueNRG1_uart.c BlueNRG1_wdg.c misc.c
  group OTA
    ../../../../../Library/BLE_Application/OTA/src/: OTA_btl.c
  group Platform_Layers
    ../../../../../Library/SDK_Eval_BlueNRG1/src/: LPS25HB.c SDK_EVAL_Com.c SDK_EVAL_Config.c SDK_EVAL_I2C.c SDK_EVAL_Led.c
  group Stack
    ../../../../../Library/Bluetooth_LE/library/: libbluenrg1_stack.a
    ../../../../../Library/cryptolib/: libcrypto.a
    ../../../../../Library/Bluetooth_LE/src/: stack_user_cfg.c
  group Startup
    ../../../../../Library/CMSIS/Device/ST/BlueNRG1/Source/: system_bluenrg1.c
  group User
    ../../src/: app_common.c BLE_MS_Formula_main.c BlueNRG1_it.c cassert.c device_list.c master.c master_slave.c slave.c
    ../../../../../Library/BLE_Application/Utils/src/: ble_utils.c
